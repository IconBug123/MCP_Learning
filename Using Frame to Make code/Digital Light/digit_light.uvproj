# Keil uVision project digit_light.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: digit_light +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: app_countdown.c bsp_timer0.c drv_7seg.c main.c scheduler.c svc_countdown.c svc_display.c drv_key.c svc_key.c
  group include
    ./src/: app_countdown.h bsp_timer0.h drv_7seg.h scheduler.h svc_countdown.h svc_display.h types.h drv_key.h svc_key.h
