# Keil uVision project assignment_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: assignment_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Source Group 1
    ./: STARTUP.A51
    ./src/: main.c
    ./include/: head.h
